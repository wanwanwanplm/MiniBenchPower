# Keil uVision project sdky.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sdky
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\User\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\Libraries\STM32F1xx_HAL_Driver\Inc\Legacy;..\FreeRTOS\include;..\FreeRTOS\CMSIS_RTOS_V2;..\FreeRTOS\portable\RVDS\ARM_CM3;..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\APP\Inc;..\APP\Inc\tasks
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../User/Src/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
  group USER
    ../User/Src/: adc.c dma.c freertos.c gpio.c i2c.c main.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c stm32f1xx_it.c usart.c
  group APP/Src
    ../APP/Src/: adc_dma.c app_state.c dac_mcp4725.c eeprom_emulate.c encoder.c pid.c protect.c protocol.c tft_st7735.c
    ../APP/Src/tasks/: task_adc.c task_comm.c task_monitor.c task_pid.c task_ui.c
  group APP/Inc
    ../APP/Inc/: adc_dma.h app_config.h app_state.h dac_mcp4725.h eeprom_emulate.h encoder.h pid.h protect.h protocol.h tft_st7735.h
    ../APP/Inc/tasks/: task_adc.h task_comm.h task_monitor.h task_pid.h task_ui.h
